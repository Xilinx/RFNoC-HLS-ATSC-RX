<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>uhd_rx_atsc</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Receive ATSC from UHD</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>antenna</value></param>
<param><key>value</key><value>TX/RX</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label0</key><value>TX/RX</value></param>
<param><key>label1</key><value>RX2</value></param>
<param><key>label</key><value>Antenna</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>TX/RX</value></param>
<param><key>option1</key><value>RX2</value></param>
<param><key>type</key><value>string</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>atsc_sym_rate</value></param>
<param><key>value</key><value>4.5e6/286*684</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ce_rate</value></param>
<param><key>value</key><value>200e6</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>195e6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>195e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>18</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,3,1,1</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>31</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>oversampled_rate</value></param>
<param><key>value</key><value>atsc_sym_rate*sps</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>6.25e6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,2,1,1</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>6.25e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>1.1</value></param>
</block>
<block>
<key>variable_uhd_device3</key>
<param><key>id</key><value>variable_uhd_device3_0</value></param>
<param><key>dev_addr</key><value>type=x300</value></param>
<param><key>dev_args</key><value>""</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>agc</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>rate</key><value>1e-5</value></param>
<param><key>reference</key><value>4.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>atsc_rx_agc</key>
<param><key>id</key><value>atsc_rx_agc_0</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fpga_module_name</key><value>noc_block_agc</value></param>
<param><key>block_index</key><value>-1</value></param>
</block>
<block>
<key>atsc_rx_dcr</key>
<param><key>id</key><value>atsc_rx_dcr_0</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fpga_module_name</key><value>noc_block_agc</value></param>
<param><key>block_index</key><value>-1</value></param>
</block>
<block>
<key>atsc_rx_dcragc</key>
<param><key>id</key><value>atsc_rx_dcragc_0</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>fpga_module_name</key><value>noc_block_agc</value></param>
<param><key>block_index</key><value>-1</value></param>
</block>
<block>
<key>atsc_rx_depad</key>
<param><key>id</key><value>atsc_rx_depad_0</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>block_index</key><value>-1</value></param>
</block>
<block>
<key>atsc_rx_fltpll</key>
<param><key>id</key><value>atsc_rx_fltpll_0</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>fpga_module_name</key><value>noc_block_agc</value></param>
<param><key>block_index</key><value>-1</value></param>
</block>
<block>
<key>atsc_rx_fpll</key>
<param><key>id</key><value>atsc_rx_fpll_0</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fpga_module_name</key><value>noc_block_agc</value></param>
<param><key>block_index</key><value>-1</value></param>
</block>
<block>
<key>atsc_rx_rsdec</key>
<param><key>id</key><value>atsc_rx_rsdec_0</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fpga_module_name</key><value>noc_block_rsdec</value></param>
<param><key>block_index</key><value>-1</value></param>
</block>
<block>
<key>atsc_rx_rxfilt</key>
<param><key>id</key><value>atsc_rx_rxfilt_0</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fpga_module_name</key><value>noc_block_agc</value></param>
<param><key>block_index</key><value>-1</value></param>
</block>
<block>
<key>blocks_ctrlport_monitor_performance</key>
<param><key>id</key><value>blocks_ctrlport_monitor_performance_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>en</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/switchlanez/working_dir/gr-dtv/rfnoc_captures/mpeg.ts</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/switchlanez/working_dir/gr-dtv/big_captures/ddc-frontend</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/switchlanez/working_dir/gr-dtv/rfnoc_captures/atsc_rx_filter_in</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/switchlanez/working_dir/gr-dtv/big_captures/ddc</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>sample_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>length</key><value>4096</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>displays</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,0,1,4</value></param>
<param><key>label0</key><value>RX Spectrum</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<block>
<key>dtv_atsc_deinterleaver</key>
<param><key>id</key><value>dtv_atsc_deinterleaver_0</value></param>
</block>
<block>
<key>dtv_atsc_depad</key>
<param><key>id</key><value>dtv_atsc_depad_0</value></param>
</block>
<block>
<key>dtv_atsc_derandomizer</key>
<param><key>id</key><value>dtv_atsc_derandomizer_0</value></param>
</block>
<block>
<key>dtv_atsc_equalizer</key>
<param><key>id</key><value>dtv_atsc_equalizer_0</value></param>
</block>
<block>
<key>dtv_atsc_fs_checker</key>
<param><key>id</key><value>dtv_atsc_fs_checker_0</value></param>
</block>
<block>
<key>dtv_atsc_rs_decoder</key>
<param><key>id</key><value>dtv_atsc_rs_decoder_0</value></param>
</block>
<block>
<key>dtv_atsc_sync</key>
<param><key>id</key><value>dtv_atsc_sync_0</value></param>
<param><key>rate</key><value>oversampled_rate</value></param>
</block>
<block>
<key>dtv_atsc_viterbi_decoder</key>
<param><key>id</key><value>dtv_atsc_viterbi_decoder_0</value></param>
</block>
<block>
<key>dtv_atsc_fpll</key>
<param><key>id</key><value>fpll</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>rate</key><value>oversampled_rate</value></param>
</block>
<block>
<key>dtv_atsc_rx_filter</key>
<param><key>id</key><value>rx_filter</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>rate</key><value>sample_rate</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_ddc</key>
<param><key>id</key><value>uhd_rfnoc_streamer_ddc_0</value></param>
<param><key>block_index</key><value>-1</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>fpga_module_name</key><value>noc_block_ddc</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>fullscale</key><value>1.0</value></param>
<param><key>input_rate</key><value>ce_rate</value></param>
<param><key>num_chans</key><value>1</value></param>
<param><key>output_rate</key><value>sample_rate</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_fifo</key>
<param><key>id</key><value>uhd_rfnoc_streamer_fifo_0</value></param>
<param><key>otw</key><value>fc32</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>block_index</key><value>-1</value></param>
<param><key>fpga_module_name</key><value>noc_block_axi_fifo_loopback</value></param>
<param><key>grvlen</key><value>1</value></param>
<param><key>type</key><value>fc32</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_fifo</key>
<param><key>id</key><value>uhd_rfnoc_streamer_fifo_0_0_1_1</value></param>
<param><key>otw</key><value>u8</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>block_index</key><value>-1</value></param>
<param><key>fpga_module_name</key><value>noc_block_axi_fifo_loopback</value></param>
<param><key>grvlen</key><value>256</value></param>
<param><key>type</key><value>u8</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_radio</key>
<param><key>id</key><value>uhd_rfnoc_streamer_radio_0</value></param>
<param><key>freq</key><value>freq</value></param>
<param><key>rx_bandwidth0</key><value>sample_rate</value></param>
<param><key>ant0</key><value>"TX/RX"</value></param>
<param><key>lo_export0</key><value>False</value></param>
<param><key>lo_source0</key><value>"internal"</value></param>
<param><key>rx_bandwidth1</key><value>56e6</value></param>
<param><key>ant1</key><value>"TX/RX"</value></param>
<param><key>lo_export1</key><value>False</value></param>
<param><key>lo_source1</key><value>"internal"</value></param>
<param><key>dcenable</key><value>True</value></param>
<param><key>otw_format</key><value>sc16</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>grvlen</key><value>1</value></param>
<param><key>gain</key><value>20</value></param>
<param><key>cpu_format</key><value>fc32</value></param>
<param><key>direction</key><value>rx</value></param>
<param><key>num_channels</key><value>1</value></param>
<param><key>radio_index</key><value>0</value></param>
<param><key>rate</key><value>sample_rate</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>stream_args</key><value></value></param>
</block>
<connection><source_block_id>agc</source_block_id><sink_block_id>dtv_atsc_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>atsc_rx_agc_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>atsc_rx_agc_0</source_block_id><sink_block_id>dtv_atsc_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>atsc_rx_dcr_0</source_block_id><sink_block_id>agc</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>atsc_rx_dcr_0</source_block_id><sink_block_id>atsc_rx_agc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>atsc_rx_dcragc_0</source_block_id><sink_block_id>dtv_atsc_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>atsc_rx_depad_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>atsc_rx_fltpll_0</source_block_id><sink_block_id>atsc_rx_dcr_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>atsc_rx_fltpll_0</source_block_id><sink_block_id>atsc_rx_dcragc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>atsc_rx_fltpll_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>atsc_rx_fpll_0</source_block_id><sink_block_id>atsc_rx_dcr_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>atsc_rx_rxfilt_0</source_block_id><sink_block_id>atsc_rx_fpll_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>rx_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fifo_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fifo_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fifo_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>agc</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>atsc_rx_agc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_deinterleaver_0</source_block_id><sink_block_id>dtv_atsc_rs_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_deinterleaver_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fifo_0_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_depad_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_derandomizer_0</source_block_id><sink_block_id>atsc_rx_depad_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_derandomizer_0</source_block_id><sink_block_id>dtv_atsc_depad_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_equalizer_0</source_block_id><sink_block_id>dtv_atsc_viterbi_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_fs_checker_0</source_block_id><sink_block_id>dtv_atsc_equalizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_rs_decoder_0</source_block_id><sink_block_id>dtv_atsc_derandomizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_sync_0</source_block_id><sink_block_id>dtv_atsc_fs_checker_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_viterbi_decoder_0</source_block_id><sink_block_id>dtv_atsc_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fpll</source_block_id><sink_block_id>atsc_rx_dcr_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fpll</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_filter</source_block_id><sink_block_id>fpll</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_ddc_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_ddc_0</source_block_id><sink_block_id>rx_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fifo_0</source_block_id><sink_block_id>atsc_rx_fltpll_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fifo_0</source_block_id><sink_block_id>atsc_rx_rxfilt_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fifo_0_0_1_1</source_block_id><sink_block_id>atsc_rx_rsdec_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_radio_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_ddc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
