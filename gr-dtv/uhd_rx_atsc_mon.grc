<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>uhd_rx_atsc</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Receive ATSC from UHD</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>antenna</value></param>
<param><key>value</key><value>TX/RX</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label0</key><value>TX/RX</value></param>
<param><key>label1</key><value>RX2</value></param>
<param><key>label</key><value>Antenna</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>TX/RX</value></param>
<param><key>option1</key><value>RX2</value></param>
<param><key>type</key><value>string</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>atsc_sym_rate</value></param>
<param><key>value</key><value>4.5e6/286*684</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>195e6</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>18</value></param>
<param><key>gui_hint</key><value>1,3,1,1</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>31</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>oversampled_rate</value></param>
<param><key>value</key><value>atsc_sym_rate*sps</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>6.25e6</value></param>
<param><key>gui_hint</key><value>1,2,1,1</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>1.1</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>agc</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>rate</key><value>1e-5</value></param>
<param><key>reference</key><value>4.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_ctrlport_monitor</key>
<param><key>id</key><value>blocks_ctrlport_monitor_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>en</key><value>True</value></param>
</block>
<block>
<key>blocks_ctrlport_monitor_performance</key>
<param><key>id</key><value>blocks_ctrlport_monitor_performance_0</value></param>
<param><key>en</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/switchlanez/working_dir/gr-dtv/rfnoc_captures/mpeg.ts</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/switchlanez/working_dir/gr-dtv/big_captures/rx_filt2pll_ccf</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/switchlanez/working_dir/gr-dtv/big_captures/pll2dcr_f</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/switchlanez/working_dir/gr-dtv/big_captures/dcr2agc_f</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/switchlanez/working_dir/hls/dc_blocker_agc/tb_out128</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/switchlanez/working_dir/gr-dtv/big_captures/sync2fsc_f</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>4096</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_3_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/switchlanez/working_dir/gr-dtv/big_captures/equ2vit_f</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1024</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_3_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/switchlanez/working_dir/gr-dtv/big_captures/vit2dei_uchar</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>256</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_3_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/switchlanez/working_dir/gr-dtv/big_captures/dei2rsd_uchar</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>256</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_3_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/switchlanez/working_dir/gr-dtv/big_captures/rsd2der_uchar</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>256</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_3_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/switchlanez/working_dir/gr-dtv/big_captures/der2dep</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>256</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_3_0_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/switchlanez/working_dir/gr-dtv/big_captures/dep_out_uchar</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_3_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/switchlanez/working_dir/gr-dtv/big_captures/fsc2equ_f</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>4096</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_3_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/switchlanez/working_dir/gr-dtv/big_captures/fsc2equ_f</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>4096</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/switchlanez/working_dir/gr-dtv/captures/ATSC RX Filter input-output/atsc_rx_filter_in</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/switchlanez/working_dir/gr-dtv/big_captures/ddc</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/switchlanez/working_dir/gr-dtv/big_captures/rxfilt</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0_0_1</value></param>
<param><key>file</key><value>/home/switchlanez/working_dir/gr-dtv/rfnoc_captures/fltpll-dcragc</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/switchlanez/working_dir/gr-dtv/big_captures/fltpll</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_multiply_const_xx</key>
<param><key>id</key><value>blocks_multiply_const_xx_0</value></param>
<param><key>const</key><value>1/3.276700480546441e+04</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>oversampled_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>length</key><value>4096</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>displays</value></param>
<param><key>gui_hint</key><value>0,0,1,4</value></param>
<param><key>label0</key><value>RX Spectrum</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<block>
<key>dtv_atsc_deinterleaver</key>
<param><key>id</key><value>dtv_atsc_deinterleaver_0</value></param>
</block>
<block>
<key>dtv_atsc_depad</key>
<param><key>id</key><value>dtv_atsc_depad_0</value></param>
</block>
<block>
<key>dtv_atsc_derandomizer</key>
<param><key>id</key><value>dtv_atsc_derandomizer_0</value></param>
</block>
<block>
<key>dtv_atsc_equalizer</key>
<param><key>id</key><value>dtv_atsc_equalizer_0</value></param>
</block>
<block>
<key>dtv_atsc_fs_checker</key>
<param><key>id</key><value>dtv_atsc_fs_checker_0</value></param>
</block>
<block>
<key>dtv_atsc_rs_decoder</key>
<param><key>id</key><value>dtv_atsc_rs_decoder_0</value></param>
</block>
<block>
<key>dtv_atsc_sync</key>
<param><key>id</key><value>dtv_atsc_sync_0</value></param>
<param><key>rate</key><value>oversampled_rate</value></param>
</block>
<block>
<key>dtv_atsc_viterbi_decoder</key>
<param><key>id</key><value>dtv_atsc_viterbi_decoder_0</value></param>
</block>
<block>
<key>dtv_atsc_fpll</key>
<param><key>id</key><value>fpll</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>rate</key><value>oversampled_rate</value></param>
</block>
<block>
<key>dtv_atsc_rx_filter</key>
<param><key>id</key><value>rx_filter</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>rate</key><value>sample_rate</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>u</value></param>
<param><key>ant0</key><value>antenna</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>usrp_freq_sink</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>sample_rate</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>gui_hint</key><value>displays@0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"RX Spectrum"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>agc</source_block_id><sink_block_id>blocks_file_sink_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>agc</source_block_id><sink_block_id>dtv_atsc_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>rx_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0_0</source_block_id><sink_block_id>rx_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0_0_0</source_block_id><sink_block_id>fpll</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0_0_1</source_block_id><sink_block_id>dtv_atsc_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0_1_0</source_block_id><sink_block_id>blocks_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0_1_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>blocks_multiply_const_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>agc</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>blocks_file_sink_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_deinterleaver_0</source_block_id><sink_block_id>blocks_file_sink_3_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_deinterleaver_0</source_block_id><sink_block_id>dtv_atsc_rs_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_depad_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_depad_0</source_block_id><sink_block_id>blocks_file_sink_3_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_depad_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_derandomizer_0</source_block_id><sink_block_id>blocks_file_sink_3_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_derandomizer_0</source_block_id><sink_block_id>dtv_atsc_depad_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_equalizer_0</source_block_id><sink_block_id>blocks_file_sink_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_equalizer_0</source_block_id><sink_block_id>blocks_file_sink_3_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_equalizer_0</source_block_id><sink_block_id>dtv_atsc_viterbi_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_fs_checker_0</source_block_id><sink_block_id>blocks_file_sink_3_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_fs_checker_0</source_block_id><sink_block_id>dtv_atsc_equalizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_rs_decoder_0</source_block_id><sink_block_id>blocks_file_sink_3_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_rs_decoder_0</source_block_id><sink_block_id>dtv_atsc_derandomizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_sync_0</source_block_id><sink_block_id>blocks_file_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_sync_0</source_block_id><sink_block_id>dtv_atsc_fs_checker_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_viterbi_decoder_0</source_block_id><sink_block_id>blocks_file_sink_3_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_viterbi_decoder_0</source_block_id><sink_block_id>dtv_atsc_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fpll</source_block_id><sink_block_id>blocks_file_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fpll</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_filter</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_filter</source_block_id><sink_block_id>fpll</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>u</source_block_id><sink_block_id>rx_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>u</source_block_id><sink_block_id>usrp_freq_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
