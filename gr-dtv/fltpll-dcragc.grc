<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>oversampled_rate</value></param>
<param><key>value</key><value>1.1*4.5e6/286*684</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>6.25e6</value></param>
</block>
<block>
<key>variable_uhd_device3</key>
<param><key>id</key><value>variable_uhd_device3_0</value></param>
<param><key>dev_addr</key><value>type=x300</value></param>
<param><key>dev_args</key><value>""</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>agc</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>rate</key><value>1e-5</value></param>
<param><key>reference</key><value>4.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>atsc_rx_dcragc</key>
<param><key>id</key><value>atsc_rx_dcragc_0</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>fpga_module_name</key><value>noc_block_agc</value></param>
<param><key>block_index</key><value>-1</value></param>
</block>
<block>
<key>atsc_rx_fltpll</key>
<param><key>id</key><value>atsc_rx_fltpll_0</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>fpga_module_name</key><value>noc_block_agc</value></param>
<param><key>block_index</key><value>-1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>file</key><value>/home/switchlanez/working_dir/gr-dtv/rfnoc_captures/fltpll-dcragc</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/switchlanez/working_dir/gr-dtv/big_captures/fltpll-dcragc_golden</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>file</key><value>/home/switchlanez/working_dir/gr-dtv/rfnoc_captures/atsc_rx_filter_in</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>sample_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1_0</value></param>
<param><key>samples_per_second</key><value>sample_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>length</key><value>256</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>dtv_atsc_fpll</key>
<param><key>id</key><value>fpll</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>rate</key><value>oversampled_rate</value></param>
</block>
<block>
<key>dtv_atsc_rx_filter</key>
<param><key>id</key><value>rx_filter</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>rate</key><value>sample_rate</value></param>
<param><key>sps</key><value>1.1</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_fifo</key>
<param><key>id</key><value>uhd_rfnoc_streamer_fifo_0</value></param>
<param><key>otw</key><value>fc32</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>block_index</key><value>-1</value></param>
<param><key>fpga_module_name</key><value>noc_block_axi_fifo_loopback</value></param>
<param><key>grvlen</key><value>1</value></param>
<param><key>type</key><value>fc32</value></param>
</block>
<connection><source_block_id>agc</source_block_id><sink_block_id>blocks_file_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>atsc_rx_dcragc_0</source_block_id><sink_block_id>blocks_throttle_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>atsc_rx_fltpll_0</source_block_id><sink_block_id>atsc_rx_dcragc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fifo_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>rx_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>agc</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fpll</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_filter</source_block_id><sink_block_id>fpll</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fifo_0</source_block_id><sink_block_id>atsc_rx_fltpll_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
